# Keil uVision project TOUCH.uvprojx, settings and files
target TOUCH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: TOUCH +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\FWLIB\inc;..\HARDWARE\TOUCH;..\HARDWARE\LVGL\GUI\porting;..\HARDWARE\LVGL\GUI\src;..\HARDWARE\LVGL;..\HARDWARE\LVGL\GUI\porting;..\HARDWARE\LVGL\GUI\src;..\HARDWARE\LVGL\GUI;..\HARDWARE\LVGL\GUI_APP;..\HARDWARE\TIMER;..\HARDWARE\LVGL\GUI_APP\demo;..\HARDWARE\SRAM;..\HARDWARE\LVGL\GUI_APP\test;..\HARDWARE\PWM
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/TOUCH/: ctiic.c gt9147.c ott2001a.c ft5206.c touch.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/PWM/: pwm.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c
  group README
    ../: readme.txt
  group lvgl_demo
    ../HARDWARE/LVGL/GUI_APP/demo/: demo_test.c
    ../HARDWARE/LVGL/GUI_APP/test/: test.c
  group lvgl_proting
    ../HARDWARE/LVGL/GUI/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group lvgl_scr
    ../HARDWARE/LVGL/GUI/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../HARDWARE/LVGL/GUI/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../HARDWARE/LVGL/GUI/src/draw/arm2d/: lv_gpu_arm2d.c
    ../HARDWARE/LVGL/GUI/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../HARDWARE/LVGL/GUI/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c
    ../HARDWARE/LVGL/GUI/src/draw/nxp/: lv_gpu_nxp.c
    ../HARDWARE/LVGL/GUI/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../HARDWARE/LVGL/GUI/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../HARDWARE/LVGL/GUI/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../HARDWARE/LVGL/GUI/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../HARDWARE/LVGL/GUI/src/extra/layouts/flex/: lv_flex.c
    ../HARDWARE/LVGL/GUI/src/extra/layouts/grid/: lv_grid.c
    ../HARDWARE/LVGL/GUI/src/extra/libs/bmp/: lv_bmp.c
    ../HARDWARE/LVGL/GUI/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../HARDWARE/LVGL/GUI/src/extra/libs/freetype/: lv_freetype.c
    ../HARDWARE/LVGL/GUI/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../HARDWARE/LVGL/GUI/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../HARDWARE/LVGL/GUI/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    ../HARDWARE/LVGL/GUI/src/extra/libs/png/: lv_png.c lodepng.c
    ../HARDWARE/LVGL/GUI/src/extra/libs/rlottie/: lv_rlottie.c
    ../HARDWARE/LVGL/GUI/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../HARDWARE/LVGL/GUI/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../HARDWARE/LVGL/GUI/src/extra/others/gridnav/: lv_gridnav.c
    ../HARDWARE/LVGL/GUI/src/extra/others/ime/: lv_ime_pinyin.c
    ../HARDWARE/LVGL/GUI/src/extra/others/imgfont/: lv_imgfont.c
    ../HARDWARE/LVGL/GUI/src/extra/others/monkey/: lv_monkey.c
    ../HARDWARE/LVGL/GUI/src/extra/others/msg/: lv_msg.c
    ../HARDWARE/LVGL/GUI/src/extra/others/snapshot/: lv_snapshot.c
    ../HARDWARE/LVGL/GUI/src/extra/themes/basic/: lv_theme_basic.c
    ../HARDWARE/LVGL/GUI/src/extra/themes/default/: lv_theme_default.c
    ../HARDWARE/LVGL/GUI/src/extra/themes/mono/: lv_theme_mono.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/animimg/: lv_animimg.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/chart/: lv_chart.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/keyboard/: lv_keyboard.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/led/: lv_led.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/list/: lv_list.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/menu/: lv_menu.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/meter/: lv_meter.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/msgbox/: lv_msgbox.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/span/: lv_span.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/spinbox/: lv_spinbox.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/spinner/: lv_spinner.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/tabview/: lv_tabview.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/tileview/: lv_tileview.c
    ../HARDWARE/LVGL/GUI/src/extra/widgets/win/: lv_win.c
    ../HARDWARE/LVGL/GUI/src/extra/: lv_extra.c
    ../HARDWARE/LVGL/GUI/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../HARDWARE/LVGL/GUI/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../HARDWARE/LVGL/GUI/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../HARDWARE/LVGL/GUI/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
